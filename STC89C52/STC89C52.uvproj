# Keil uVision project STC89C52.uvproj, settings and files
target Program (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC89C52 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: main.c
